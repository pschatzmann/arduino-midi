#pragma once
#include "ConfigMidi.h"

#if MIDI_ACTIVE

#include "MidiCommon.h"
#include "MidiLogger.h"
#include "MidiParser.h"
#include "MidiUsbPacket.h"

namespace midi {

/***************************************************/
/*! \class MidiUsbBase
    \brief Common functionality of the USB MIDI classes (MidiUsbDevice and
    MidiUsbHost): the outgoing messages are converted to USB-MIDI packets and
    the received packets are parsed and forwarded to the MidiAction.

    A platform specific subclass only needs to implement readPacket() and
    writePacket(). Call loop() regularly in the Arduino loop() to process
    the received messages.

    by Phil Schatzmann
*/
/***************************************************/
class MidiUsbBase : public MidiCommon {
 public:
  MidiUsbBase() = default;
  /// Constructor with the MidiAction which receives the parsed messages and
  /// an optional channel filter (-1 = all channels)
  MidiUsbBase(MidiAction* action, int channelFilter = -1) {
    if (action != nullptr) setMidiAction(*action);
    setFilterReceivingChannel(channelFilter);
  }
  virtual ~MidiUsbBase() = default;

  /// Defines a custom (subclassed) MidiParser which is used instead of the
  /// default parser: the parser is not deleted
  void setMidiParser(MidiParser& parser) { p_parser = &parser; }

  /// Defines the MidiAction which receives the parsed messages
  void setMidiAction(MidiAction& action) override {
    MidiCommon::setMidiAction(action);
    updateDefaultParser();
  }

  /// Activates a filter on the receiving channel (-1 = all channels)
  void setFilterReceivingChannel(int channel) override {
    MidiCommon::setFilterReceivingChannel(channel);
    updateDefaultParser();
  }

  /// Defines the USB-MIDI cable number (0..15) that is used for sending
  void setCable(uint8_t cableNo) { cable_no = cableNo & 0x0F; }

  /// Provides the USB-MIDI cable number that is used for sending
  uint8_t cable() const { return cable_no; }

  /// Returns true if the USB connection is active
  bool isConnected() { return getConnectionStatus() == Connected; }

  /// Sends a single complete MIDI message (e.g. a channel or realtime
  /// message given as bytes): returns false if it can not be sent
  bool writeMessage(const uint8_t* msg, int len) {
    uint8_t packet[4];
    if (!MidiUsbPacket::fromMessage(cable_no, msg, len, packet)) {
      MIDI_LOGW("MidiUsb: unsupported message");
      return false;
    }
    return writePacket(packet);
  }

  /// Sends a raw 4 byte USB-MIDI event packet
  virtual bool writePacket(const uint8_t packet[4]) = 0;

  /// Reads a raw 4 byte USB-MIDI event packet: returns false if no packet
  /// is available
  virtual bool readPacket(uint8_t packet[4]) = 0;

  /// Processes the received MIDI messages: call it in the Arduino loop().
  /// Returns true if some data was processed.
  virtual bool loop() {
    bool processed = false;
    uint8_t packet[4];
    // limit the work per call so that the loop stays responsive
    for (int j = 0; j < max_packets_per_loop && readPacket(packet); j++) {
      MidiParser* parser = activeParser();
      if (parser != nullptr) parser->parseUsb(packet, 4);
      processed = true;
    }
    return processed;
  }

 protected:
  MidiParser default_parser;
  MidiParser* p_parser = nullptr;
  uint8_t cable_no = 0;
  int max_packets_per_loop = 64;

  /// Provides the custom parser or the default parser (if a MidiAction is
  /// defined): returns nullptr if the received messages can be dropped
  MidiParser* activeParser() {
    if (p_parser != nullptr) return p_parser;
    if (pMidiAction != nullptr) return &default_parser;
    return nullptr;
  }

  void updateDefaultParser() {
    default_parser.begin(pMidiAction, receivingChannel);
  }

  /// Converts the message generated by MidiCommon to a USB-MIDI packet
  void writeData(MidiMessage* msg, int len) override {
    uint8_t bytes[3] = {msg->status, msg->arg1, msg->arg2};
    writeMessage(bytes, len + 1);
  }
};

}  // namespace midi

#endif
